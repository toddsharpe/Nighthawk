SRC_URI += "file://user_2023-06-13-04-12-00.cfg \
            file://user_2023-06-13-04-36-00.cfg \
            file://user_2023-06-14-03-02-00.cfg \
            file://user_2023-06-14-04-37-00.cfg \
            file://user_2023-06-14-04-52-00.cfg \
            file://user_2023-06-17-05-53-00.cfg \
            "

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

